IMAGE_INSTALL += " \
    can-utils \
    libsocketcan \
    kernel-modules \
    strace \
    vim \
    htop \
    packagegroup-core-ssh-openssh \
    lsof \
"
